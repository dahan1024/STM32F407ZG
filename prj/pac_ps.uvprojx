# Keil uVision project pac_ps.uvprojx, settings and files
target pac_ps (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: pac_ps +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\cli;..\drivers;..\include;..\lib\atof;..\lib\CMSIS\Include;..\lib\CMSIS\STM32F4xx\Include;..\lib\STM32F4x7_ETH_Driver\inc;..\lib\STM32F4xx_StdPeriph_Driver\inc;..\lwip;..\lwip\lwip_app\lwip_comm;..\lwip\lwip-1.4.1\src\include;..\malloc;..\periph\ad9543;..\periph\eeprom;..\periph\ethernet;..\periph\fpga;..\periph\w25qxx;..\user
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group cli
    ../cli/: cli_server.c lv1.c lv2_ad9543.c lv2_eeprom.c lv2_fpga.c lv2_fsmc_sram.c lv2_ver.c lv2_w25qxx.c
  group drivers
    ../drivers/: drv_crc.c drv_delay.c drv_fsmc_sram.c drv_gpio.c drv_i2c.c drv_spi.c drv_usart.c
  group atof
    ../lib/atof/: atof.c
  group CMSIS
    ../lib/CMSIS/STM32F4xx/Source/: startup_stm32f40_41xxx.s stm32f4xx_it.c system_stm32f4xx.c
  group STM32F4x7_ETH_Driver
    ../lib/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group STM32F4xx_StdPeriph_Driver
    ../lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group lwip_arch
    ../lwip/arch/: sys_arch.c
  group lwip_app
    ../lwip/lwip_app/lwip_comm/: lwip_comm.c
  group lwip_core
    ../lwip/lwip-1.4.1/src/core/: def.c init.c mem.c netif.c
  group lwip_netif
    ../lwip/lwip-1.4.1/src/netif/: etharp.c ethernetif.c ethpac.c
  group malloc
    ../malloc/: malloc.c
  group periph
    ../periph/ad9543/: ad9543.c
    ../periph/eeprom/: at24cxx.c eeprom.c
    ../periph/ethernet/: lan8720.c
    ../periph/fpga/: fpga.c
    ../periph/w25qxx/: w25qxx.c
  group user
    ../user/: main.c system.c
